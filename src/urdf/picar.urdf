Commit message: update code

File: src/urdf/picar.urdf (robot description, URDF)
Before this commit: robot pi_car, 8 links, 7 joints
Joints:
- joint base_joint: origin xyz=0 0 50 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
